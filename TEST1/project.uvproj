# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Nixie.h Nixie.c MatrixKey.h Delay.c Delay.h MatrixKey.c Buzzer.c Buzzer.h Timer0.c Timer0.h XPT2046.h XPT2046.c
